Commit message: change mass value of simpleHumanoid abstract

File: data/simpleHumanoid/urdf/simpleHumanoid_trunk.urdf (robot description, URDF)
Before this commit: robot simpleHumanoid_trunk, 1 links, 0 joints
Links:
- link simpleHumanoid_trunk_root: mass 10 -> 70
